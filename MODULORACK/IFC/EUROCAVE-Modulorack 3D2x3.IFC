Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Modulorack 3D.IFC
Time: 2019-08-23T07:32:47
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Coulisse Droite (2)
In: Default Storey
Material: Steel

# IfcBeam: Coulisse Gauche (2)
In: Default Storey
Material: Steel

# IfcBeam: Ecrous (10)
In: Default Storey
Material: Steel

# IfcBeam: GlissièreGauche (2)
In: Default Storey
Material: Steel

# IfcBeam: Rondelle évantail (4)
In: Default Storey
Material: Steel

# IfcBeam: Vis TF Crus M4 X 16_vis FB S M 4 X 16 (8)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: GlissièreDroite (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Vis TF Crus M4 X 16_vis FB S M 4 X 16 (2)
In: Default Storey
Material: Steel
