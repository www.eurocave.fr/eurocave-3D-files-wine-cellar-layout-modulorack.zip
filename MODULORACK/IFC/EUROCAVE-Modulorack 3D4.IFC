Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Modulorack 3D4.IFC
Time: 2019-08-23T07:33:24
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Coulisse Droite (2)
In: Default Storey
Material: Steel

# IfcBeam: Coulisse Gauche (2)
In: Default Storey
Material: Steel

# IfcBeam: Ecrous (5)
In: Default Storey
Material: Steel

# IfcBeam: GlissièreDroite (2)
In: Default Storey
Material: Steel

# IfcBeam: GlissièreGauche (2)
In: Default Storey
Material: Steel

# IfcBeam: Rivet pop Ø4,8_L corps 16.9 (2)
In: Default Storey
Material: 0

# IfcBeam: Rivet pop Ø4,8_L corps 24.8
In: Default Storey
Material: 0

# IfcBeam: Rondelle M5
In: Default Storey
Material: 0

# IfcBeam: Rondelle évantail (2)
In: Default Storey
Material: Steel

# IfcBeam: Vis TF Crus M4 X 16_vis FB S M 4 X 16 (7)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chanfrein1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Ecrous (5)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Extrusion1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extrusion1[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Modulorack-Barre-laterale (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Modulorack-Cerceau (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Modulorack-Raidisseur (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Rivet pop Ø4,8_L corps 16.9 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Rivet pop Ø4,8_L corps 24.8
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Rondelle M5 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Rondelle évantail (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Symétrie2 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Vis TF Crus M4 X 16_vis FB S M 4 X 16 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
